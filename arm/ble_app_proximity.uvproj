# Keil uVision project ble_app_proximity.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_proximity +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\hardware;..\hardware\htu21d;..\hardware\oled;..\hardware\rtc;..\hardware\wdt;.\Include;.\Include\app_common;.\Include\ble;.\Include\ble\ble_services;.\Include\ble\softdevice;..\arm
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./Source/templates/: system_nrf51.c
    ./Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ../: main.c communication_procotol.c
    ./: ble_app_main.c ble_includes.h
  group Services
    ../: ble_nus.c
    ./Source/ble/ble_services/: ble_bas.c ble_ias.c ble_ias_c.c ble_lls.c ble_tps.c
  group Hardware
    ../hardware/htu21d/: htu21d.c
    ../hardware/oled/: oled.c
    ../hardware/rtc/: rtc0.c
    ../hardware/wdt/: wdt.c
  group Libraries
    ../: nrf_delay.c twi_sw_master.c
    ./Source/ble/: ble_advdata.c ble_bondmngr.c ble_conn_params.c ble_debug_assert_handler.c ble_error_log.c ble_flash.c ble_radio_notification.c ble_stack_handler.c
    ./Source/app_common/: app_button.c app_gpiote.c app_timer.c
    ./Source/ble/ble_services/: ble_srv_common.c
    ./Source/simple_uart/: simple_uart.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_proximity +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
